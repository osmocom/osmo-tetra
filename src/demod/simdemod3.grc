options:
  parameters:
    author: Jacek Lipkowski SQ5BPF
    description: cqpsk demodulator for tetra. based on  pi4dqpsk_rx.grc (by 'Luca Bortolotti' @optiluca) from https://gitlab.com/larryth/tetra-kit/ . It is meant as a replacement for simdemod2.py, taked the data from stdin, and dumpd demodulated data to STDOUT. Also sends via UDP the information how much the signal is mistuned (this option is disabled for the version committed to osmo-tetra)
    generate_options: no_gui
    id: simdemod3
    output_language: python
    run_options: run
    title: DQPSK demodulator for Telive, with the AFC packet sending option disabled
  states: {}

blocks:
- name: TETRA_HACK_IP
  id: variable
  parameters:
    value: os.getenv('TETRA_HACK_IP') if os.getenv('TETRA_HACK_IP') else "127.0.0.1"
  states: {state: disabled}
- name: TETRA_HACK_PORT
  id: variable
  parameters:
    value: int(os.getenv('TETRA_HACK_PORT')) if os.getenv('TETRA_HACK_PORT') else 7379
  states: {state: disabled}
- name: TETRA_HACK_RXID
  id: variable
  parameters:
    value: int(os.getenv('TETRA_HACK_RXID')) if os.getenv('TETRA_HACK_RXID') else 0
  states: {state: disabled}
- name: arity
  id: variable
  parameters:
    value: '4'
  states: {}
- name: channel_rate
  id: variable
  parameters:
    value: '36000'
  states: {}
- name: constel
  id: variable_constellation
  parameters:
    const_points: '[1-1j, 1+1j, -1-1j, 1-1j]'
    precision: '8'
    soft_dec_lut: '''auto'''
    type: dqpsk
  states: {}
- name: decim
  id: variable
  parameters:
    value: '32'
  states: {}
- name: nfilts
  id: variable
  parameters:
    value: '32'
  states: {}
- name: rrc_taps
  id: variable
  parameters:
    value: firdes.root_raised_cosine(nfilts, nfilts, 1.0/float(sps), 0.35, 11*sps*nfilts)
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '2000000'
  states: {}
- name: sps
  id: variable
  parameters:
    value: '2'
  states: {}
- name: variable_adaptive_algorithm_0
  id: variable_adaptive_algorithm
  parameters:
    cons: constel
    modulus: '1'
    step_size: '10e-3'
    type: cma
  states: {}
- name: Author_note
  id: note
  parameters:
    note: 'This is originally part of the telive software: https://github.com/sq5bpf/telive '
  states: {}
- name: analog_feedforward_agc_cc_0
  id: analog_feedforward_agc_cc
  parameters:
    num_samples: '8'
    reference: '1'
  states: {}
- name: blocks_file_descriptor_source_0
  id: blocks_file_descriptor_source
  parameters:
    fd: '0'
    repeat: 'False'
    type: complex
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    num_inputs: '3'
    type: float
  states: {}
- name: blocks_unpack_k_bits_bb_0
  id: blocks_unpack_k_bits_bb
  parameters:
    k: constel.bits_per_symbol()
  states: {}
- name: digital_constellation_decoder_cb_0
  id: digital_constellation_decoder_cb
  parameters:
    constellation: constel
  states: {}
- name: digital_diff_phasor_cc_0
  id: digital_diff_phasor_cc
  parameters: {}
  states: {}
- name: digital_fll_band_edge_cc_0
  id: digital_fll_band_edge_cc
  parameters:
    filter_size: '45'
    rolloff: '0.35'
    samps_per_sym: sps
    type: cc
    w: cmath.pi/100.0
  states: {}
- name: digital_linear_equalizer_0
  id: digital_linear_equalizer
  parameters:
    alg: variable_adaptive_algorithm_0
    num_taps: '15'
    sps: sps
  states: {}
- name: digital_map_bb_0
  id: digital_map_bb
  parameters:
    map: constel.pre_diff_code()
  states: {}
- name: digital_pfb_clock_sync_xxx_0
  id: digital_pfb_clock_sync_xxx
  parameters:
    filter_size: nfilts
    init_phase: nfilts/2
    loop_bw: 2*cmath.pi/100.0
    max_dev: '1.5'
    osps: sps
    sps: sps
    taps: rrc_taps
    type: ccf
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import cmath
  states: {}
- name: import_1
  id: import
  parameters:
    imports: import os
  states: {}
- name: send_udp_to_telive
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr
      import socket

      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Embedded Python Block - periodically send UDP packet to telive"""

          def __init__(self, ntimes=10, rxid=0, port=7379, ip="127.0.0.1",scaling=10):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='Send UDP messages to telive',   # will show up in GRC
                  in_sig=[np.float32],
                  out_sig=None
              )
              # if an attribute with the same name as a parameter is found,
              # a callback is registered (properties work, too).
              self.sock = socket.socket(socket.AF_INET,socket.SOCK_DGRAM)
              self.counter=0
              self.ntimes=ntimes
              self.tetra_hack_rxid=int(rxid)
              self.tetra_hack_ip=str(ip)
              self.tetra_hack_port=int(port)
              self.tetra_hack_scaling=scaling
              
              

          def work(self, input_items, output_items):
              """example: multiply with constant"""
              self.counter=(self.counter+1)%self.ntimes
              if self.counter==0:
                  mmm="TETMON_begin FUNC:AFCVAL AFC:%i RX:%i TETMON_end" % ( int (input_items[0][0] * self.tetra_hack_scaling * - 1.0), self.tetra_hack_rxid)
                  message=bytes(mmm, "utf-8")
                  self.sock.sendto(message, (self.tetra_hack_ip, self.tetra_hack_port))
              return len(input_items [0])
    ip: TETRA_HACK_IP
    ntimes: '5'
    port: TETRA_HACK_PORT
    rxid: TETRA_HACK_RXID
    scaling: '100'
  states: {state: disabled}
- name: stdout_sink
  id: blocks_file_descriptor_sink
  parameters:
    fd: '1'
    type: byte
  states: {}

connections:
- [analog_feedforward_agc_cc_0, '0', digital_fll_band_edge_cc_0, '0']
- [blocks_file_descriptor_source_0, '0', analog_feedforward_agc_cc_0, '0']
- [blocks_unpack_k_bits_bb_0, '0', stdout_sink, '0']
- [digital_constellation_decoder_cb_0, '0', digital_map_bb_0, '0']
- [digital_diff_phasor_cc_0, '0', digital_constellation_decoder_cb_0, '0']
- [digital_fll_band_edge_cc_0, '0', digital_pfb_clock_sync_xxx_0, '0']
- [digital_fll_band_edge_cc_0, '1', blocks_null_sink_0, '0']
- [digital_fll_band_edge_cc_0, '1', send_udp_to_telive, '0']
- [digital_fll_band_edge_cc_0, '2', blocks_null_sink_0, '1']
- [digital_fll_band_edge_cc_0, '3', blocks_null_sink_0, '2']
- [digital_linear_equalizer_0, '0', digital_diff_phasor_cc_0, '0']
- [digital_map_bb_0, '0', blocks_unpack_k_bits_bb_0, '0']
- [digital_pfb_clock_sync_xxx_0, '0', digital_linear_equalizer_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.5.1
